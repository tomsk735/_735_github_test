# IAR project Split_str.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x MDR1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: $EW_DIR$\arm\SPL_CODE\SPL\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc; $EW_DIR$\arm\SPL_CODE\SPL\CMSIS\CM3\CoreSupport; $EW_DIR$\arm\SPL_CODE\SPL; $EW_DIR$\arm\SPL_CODE\1986BE9x; $EW_DIR$\arm\SPL_CODE\SPL\MDR32F9Qx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Split_str.srec
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: Split_str.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    ./: main.cpp
    $EW_DIR$/arm/SPL_CODE/SPL/CMSIS/CM3/DeviceSupport/MDR32F9Qx/inc/: MDR32Fx.h
    $EW_DIR$/arm/SPL_CODE/SPL/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/iar/: startup_MDR32F9Qx.s system_MDR32F9Qx.c system_MDR32F9Qx.h
